<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_ax100</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_cutoff</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_filepath</value></param>
<param><key>value</key><value>"/home/rei/sampleAR2300IQ/full.bin"</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>target_samp_rate/(20*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>"" + str(source_filepath) </value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>target_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ccsds_scramble</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>crc_check</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>descramble</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>doppler_command_source</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_dc_bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>fsk_ax100_decoded</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>lpf_cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
<param><key>width</key><value>lpf_cutoff/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>partial_iq_sink</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>AR2300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>445e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1125000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>target_samp_rate</value></param>
<param><key>interp</key><value>baud_rate*4</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>reed_solomon</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>sattools_asm_golay_decoder</key>
<param><key>id</key><value>sattools_asm_golay_decoder_0</value></param>
<param><key>asm_threshold</key><value>3</value></param>
<param><key>asm</key><value>'{:b}'.format(sync_word)</value></param>
<param><key>bitrate</key><value>baud_rate</value></param>
<param><key>ccsds_randomize</key><value>bool(ccsds_scramble)</value></param>
<param><key>ccsds_rs</key><value>bool(reed_solomon)</value></param>
<param><key>crc32c</key><value>bool(crc_check)</value></param>
</block>
<block>
<key>sattools_asm_golay_decoder</key>
<param><key>id</key><value>sattools_asm_golay_decoder_0_0</value></param>
<param><key>asm_threshold</key><value>3</value></param>
<param><key>asm</key><value>'{:b}'.format(sync_word)</value></param>
<param><key>bitrate</key><value>baud_rate</value></param>
<param><key>ccsds_randomize</key><value>bool(ccsds_scramble)</value></param>
<param><key>ccsds_rs</key><value>bool(reed_solomon)</value></param>
<param><key>crc32c</key><value>bool(crc_check)</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>freq_offset_dc_bias</value></param>
<param><key>radio_antenna</key><value>radio_antenna</value></param>
<param><key>radio_center_freq</key><value>radio_center_freq</value></param>
<param><key>radio_device_address</key><value>radio_device_address</value></param>
<param><key>radio_gain</key><value>radio_gain</value></param>
<param><key>radio_samp_rate</key><value>radio_samp_rate</value></param>
<param><key>radio</key><value>radio</value></param>
<param><key>target_samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value>"" + waterfall_image_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>0x930b51de</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_image_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>sattools_asm_golay_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>sattools_asm_golay_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doppler_command_source</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>out</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sattools_asm_golay_decoder_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>sattools_asm_golay_decoder_0</source_block_id><sink_block_id>fsk_ax100_decoded</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sattools_asm_golay_decoder_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>sattools_asm_golay_decoder_0_0</source_block_id><sink_block_id>fsk_ax100_decoded</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>partial_iq_sink</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
