<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>starcoder_cw_decoder</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>CW_satnogs_decoded</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0_0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>6553600</value></param>
<param><key>rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>w</key><value>2*3.1416/400.0</value></param>
<param><key>max_freq</key><value>2*3.1416*200e3/audio_samp_rate</value></param>
<param><key>min_freq</key><value>-2*3.1416*200e3/audio_samp_rate</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>10000</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>500</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>alpha</key><value>.0003</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>read</value></param>
<param><key>packet_len</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>read</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cw_wpm</value></param>
<param><key>label</key><value>CW WPM</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>doppler_command_source</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_dc_bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>2.5e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>width</key><value>.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>partial_iq_sink</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>AR2300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>445e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1125000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>target_samp_rate</value></param>
<param><key>interp</key><value>audio_samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>1024</value></param>
<param><key>samp_rate</key><value>audio_samp_rate</value></param>
<param><key>sym_rate</key><value>10</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_cw_to_symbol</key>
<param><key>id</key><value>starcoder_cw_to_symbol_0</value></param>
<param><key>threshold</key><value>10000</value></param>
<param><key>conf_level</key><value>.7</value></param>
<param><key>sampling_rate</key><value>audio_samp_rate/4</value></param>
<param><key>wpm</key><value>cw_wpm</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>freq_offset_dc_bias</value></param>
<param><key>radio_antenna</key><value>radio_antenna</value></param>
<param><key>radio_center_freq</key><value>radio_center_freq</value></param>
<param><key>radio_device_address</key><value>radio_device_address</value></param>
<param><key>radio_gain</key><value>radio_gain</value></param>
<param><key>radio_samp_rate</key><value>radio_samp_rate</value></param>
<param><key>radio</key><value>radio</value></param>
<param><key>target_samp_rate</key><value>target_bandwidth if target_bandwidth != 112500 else target_samp_rate</value></param>
</block>
<block>
<key>starcoder_morse_decoder</key>
<param><key>id</key><value>starcoder_morse_decoder_0</value></param>
<param><key>min_frame_len</key><value>4</value></param>
<param><key>unrecognized_char</key><value>ord('#')</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value></value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>target_bandwidth</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_bandwidth</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>threshold_printer</value></param>
<param><key>_source_code</key><value># 
# Copyright 2018 Infostellar. Inc,
#
# This is free software; you can redistribute it and/or modify
# it under the terms of the GNU General Public License as published by
# the Free Software Foundation; either version 3, or (at your option)
# any later version.
#
# This software is distributed in the hope that it will be useful,
# but WITHOUT ANY WARRANTY; without even the implied warranty of
# MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
# GNU General Public License for more details.
#
# You should have received a copy of the GNU General Public License
# along with this software; see the file COPYING.  If not, write to
# the Free Software Foundation, Inc., 51 Franklin Street,
# Boston, MA 02110-1301, USA.
#
#############################
# 
# starcoder_CW_threshold_printer
#
# The aim of this "asyncronous" GNURadio python block is to read a tagged stream of values
# containing the Mag^2 of the signal, with RMS, multiplied by 2 (amplitude) and decimated 10.000 times.
# This reading corresponds to the averaged amplitude of the received signal.
# This block processes tries to detect when a morse signal is incoming, and adjusts its output to be
# a suitable threshold value for the "CW to Symbols" block (modified to accept real time threshold vars).
# When no morse signal is detected, it sets a threshold slightly over the noise in order to avoid
# reading erroneous symbols.
#
# By selecting "Straight Mode" to True, the decided threshold will be such that only signal
# with higher than "Hard Threshold" power value is readed. By selecting False, in addition to the 
# "Hard Threshold" value, other aspects are taken into account as well.

import numpy as np
from gnuradio import gr
import pmt

class threshold_printer(gr.basic_block):  # basic_block class for asynchronous block type
    
    def __init__(self, straight_mode=False, hard_threshold = 20):
        gr.basic_block.__init__(
            self,
            name='Threshold printer',
            in_sig=None,
            out_sig=None,
        )

	self.hard_threshold = hard_threshold
	self.straight_mode = straight_mode
	self.triggered = 0
	self.msga = 1000
	self.message_port_register_out(pmt.intern('out')) 	#Registration of the output port
        self.message_port_register_in(pmt.intern('in'))		#Registration of the input port
        self.set_msg_handler(pmt.intern('in'), self.handle_msg)	#Action handle message call

    def handle_msg(self, msg):

	msg0 = pmt.to_python(msg)[1][0]	#Convert PMT to python object (is a tuple). Extract 1st
					#element of tuple (is np.ndarray) and extract 1st element
					# of ndarray. Finally we get a float32.
	thr0 = float(100)

	###### Straight mode ######
	if self.straight_mode:
		if msg0 &gt; self.hard_threshold:		# When the signal exceeds "hard threshold".
			thr0 = float(msg0 / 3)		# Take 1/3 of it's power as threshold.
		else:
			thr0 = float(msg0 + 3)		# Keep the threshold away from the noise.
        ###### Normal mode ########
	else:
		if (self.triggered &lt; 3) &amp; (msg0/self.msga &gt; 6): # When it is not triggered and
								# a sudden jump is detected.
			thr0 = float(msg0 / 2)			# Take 1/2 of it's power as threshold.
			self.triggered = 15			# Set the trigger.
		elif self.triggered &gt; 3:
			thr0 = float(msg0 / 2)			# Signal 1/2 when triggered.
		else:
			thr0 = float(msg0 + 3)			# Stay away from noise.

		if msg0 &gt; self.hard_threshold:		# When the signal exceeds "hard threshold". 
			thr0 = float(msg0 / 3)		# Take 1/3 of it's power as threshold.

		self.msga = msg0			# Previous value container.
		
	self.triggered = self.triggered - 1.		# Trigger discounter.

	thr = pmt.to_pmt(thr0) 				# Convert the "1/N" threshold value in msg0 to pmt
	thr_pair = pmt.cons(thr,thr) 			# Convert thr to a "pmt pair"
	self.message_port_pub(pmt.intern('out'),thr_pair) # Send the thr to "CW to Symbols".

######### Low power mode - experimental:
#		if (self.triggered &lt; 3) &amp; (msg0/self.msga &gt; 2):
#			thr0 = float(msg0/2)
#			self.triggered = 20			
#		elif self.triggered &gt; 3:
#			thr0 = float(msg0/2)
#		else:
#			thr0 = float(msg0+2)
#		if msg0 &gt; 10:
#			thr0 = float(msg0/3)
#			self.triggered = 10
#		self.msga = msg0
</value></param>
<param><key>hard_threshold</key><value>20</value></param>
<param><key>straight_mode</key><value>False</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>starcoder_cw_to_symbol_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>threshold_printer</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>doppler_command_source</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>out</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_agc_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>partial_iq_sink</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_cw_to_symbol_0</source_block_id><sink_block_id>starcoder_morse_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_morse_decoder_0</source_block_id><sink_block_id>CW_satnogs_decoded</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>threshold_printer</source_block_id><sink_block_id>starcoder_cw_to_symbol_0</sink_block_id><source_key>out</source_key><sink_key>act_threshold</sink_key></connection>
</flow_graph>
