<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_dc_bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ground_station_id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>plan_id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>USRP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>445e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_port_number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_groundstation_api</key>
<param><key>id</key><value>starcoder_groundstation_api_0</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>groundstation_id</key><value>ground_station_id</value></param>
<param><key>plan_id</key><value>plan_id</value></param>
<param><key>api_key</key><value>""</value></param>
<param><key>api_url</key><value>stellarstation_api_url</value></param>
<param><key>stream_tag</key><value>""</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>starcoder_groundstation_api_doppler</key>
<param><key>id</key><value>starcoder_groundstation_api_doppler_0</value></param>
<param><key>corrections_per_second</key><value>20</value></param>
<param><key>downlink_frequency</key><value>radio_center_freq</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>groundstation_id</key><value>ground_station_id</value></param>
<param><key>plan_id</key><value>plan_id</value></param>
<param><key>api_key</key><value>""</value></param>
<param><key>api_url</key><value>stellarstation_api_url</value></param>
<param><key>uplink_frequency</key><value>0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>freq_offset_dc_bias</value></param>
<param><key>radio_antenna</key><value>radio_antenna</value></param>
<param><key>radio_center_freq</key><value>radio_center_freq</value></param>
<param><key>radio_device_address</key><value>radio_device_address</value></param>
<param><key>radio_gain</key><value>radio_gain</value></param>
<param><key>radio_samp_rate</key><value>radio_samp_rate</value></param>
<param><key>radio_port_number</key><value>radio_port_number</value></param>
<param><key>radio</key><value>radio</value></param>
<param><key>target_samp_rate</key><value>target_bandwidth if target_bandwidth != 112500 else target_samp_rate</value></param>
</block>
<block>
<key>starcoder_pmt_to_pdu</key>
<param><key>id</key><value>starcoder_pmt_to_pdu_0</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>filename</key><value>waterfall_image_file_path</value></param>
<param><key>mode</key><value>0</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>target_bandwidth</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stellarstation_api_url</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_bandwidth</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_image_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>starcoder_pmt_to_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_groundstation_api_doppler_0</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>downlink_shift</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_pmt_to_pdu_0</source_block_id><sink_block_id>starcoder_groundstation_api_0</sink_block_id><source_key>out</source_key><sink_key>iq</sink_key></connection>
</flow_graph>
