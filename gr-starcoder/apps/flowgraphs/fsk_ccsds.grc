<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_ccsds</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc_a</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frame_size</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc_b</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frame_size</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packlen</value></param>
<param><key>value</key><value>255*8*interleaving</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/home/agwuser/starcoder-debug/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1, 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(round(float(target_samp_rate)/baud_rate))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_float</value></param>
<param><key>value</key><value>float(target_samp_rate)/baud_rate</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>400000</value></param>
<param><key>rate</key><value>.01</value></param>
<param><key>reference</key><value>.7</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>target_samp_rate/(20*math.pi*baud_rate/8.0)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>label</key><value>Baud rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>prefix + plan_id +"_nonStellarStation_IQ.raw"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>prefix + plan_id +"_preRS.dat"</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>prefix + plan_id +"_postRS.dat"</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_a</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_b</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xA9</value></param>
<param><key>reset_tag_key</key><value>"packet_len"</value></param>
<param><key>seed</key><value>0xFF</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0</value></param>
<param><key>access_code</key><value>sync</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0_0</value></param>
<param><key>access_code</key><value>sync</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>.2</value></param>
<param><key>ted_gain</key><value>0.09501613+1.32802387/(1+(sps_float/28.7271)**2.541608)</value></param>
<param><key>nfilters</key><value>nfilts</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_PFB_MF</value></param>
<param><key>loop_bw</key><value>3.1416/10</value></param>
<param><key>max_dev</key><value>0.01</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>rrc_taps</value></param>
<param><key>sps</key><value>sps_float</value></param>
<param><key>ted_type</key><value>digital.TED_SIGNUM_TIMES_SLOPE_ML</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_a</value></param>
<param><key>decoder_list</key><value>dec_cc_a</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_b</value></param>
<param><key>decoder_list</key><value>dec_cc_b</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_dc_bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ground_station_id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interleaving</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>baud_rate*.55</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
<param><key>width</key><value>baud_rate*.55/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>plan_id</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>USRP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>445e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_port_number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>satellites_decode_rs_interleaved</key>
<param><key>id</key><value>satellites_decode_rs_interleaved_0</value></param>
<param><key>basis</key><value>1</value></param>
<param><key>codewords</key><value>interleaving</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>satellites_fixedlen_tagger</key>
<param><key>id</key><value>satellites_fixedlen_tagger_0_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>packlen</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>satellites_fixedlen_tagger</key>
<param><key>id</key><value>satellites_fixedlen_tagger_0_0_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>packlen</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_groundstation_api</key>
<param><key>id</key><value>starcoder_groundstation_api_0</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>groundstation_id</key><value>ground_station_id</value></param>
<param><key>plan_id</key><value>plan_id</value></param>
<param><key>api_key</key><value>""</value></param>
<param><key>api_url</key><value>stellarstation_api_url</value></param>
<param><key>stream_tag</key><value>""</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>starcoder_groundstation_api_doppler</key>
<param><key>id</key><value>starcoder_groundstation_api_doppler_0</value></param>
<param><key>corrections_per_second</key><value>20</value></param>
<param><key>downlink_frequency</key><value>radio_center_freq</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>groundstation_id</key><value>ground_station_id</value></param>
<param><key>plan_id</key><value>plan_id</value></param>
<param><key>api_key</key><value>""</value></param>
<param><key>api_url</key><value>stellarstation_api_url</value></param>
<param><key>uplink_frequency</key><value>0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>freq_offset_dc_bias</value></param>
<param><key>radio_antenna</key><value>radio_antenna</value></param>
<param><key>radio_center_freq</key><value>radio_center_freq</value></param>
<param><key>radio_device_address</key><value>radio_device_address</value></param>
<param><key>radio_gain</key><value>radio_gain</value></param>
<param><key>radio_samp_rate</key><value>radio_samp_rate</value></param>
<param><key>radio_port_number</key><value>radio_port_number</value></param>
<param><key>radio</key><value>radio</value></param>
<param><key>target_samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>starcoder_pmt_to_pdu</key>
<param><key>id</key><value>starcoder_pmt_to_pdu_0_0</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value>"" + waterfall_image_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stellarstation_api_url</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync</value></param>
<param><key>label</key><value>Syncword</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"00011010110011111111110000011101"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Syncword threshold</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>iq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>iq</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_image_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>fec_extended_decoder_b</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_a</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_b</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0_0_0</source_block_id><sink_block_id>satellites_decode_rs_interleaved_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>satellites_fixedlen_tagger_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0_0</source_block_id><sink_block_id>satellites_fixedlen_tagger_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>fec_extended_decoder_a</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_a</source_block_id><sink_block_id>blocks_not_xx_a</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_b</source_block_id><sink_block_id>blocks_not_xx_b</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_interleaved_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_interleaved_0</source_block_id><sink_block_id>starcoder_groundstation_api_0</sink_block_id><source_key>out</source_key><sink_key>bitstream</sink_key></connection>
<connection><source_block_id>satellites_fixedlen_tagger_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_fixedlen_tagger_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>starcoder_pmt_to_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_groundstation_api_doppler_0</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>downlink_shift</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_pmt_to_pdu_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>starcoder_groundstation_api_0</sink_block_id><source_key>out</source_key><sink_key>iq</sink_key></connection>
</flow_graph>
