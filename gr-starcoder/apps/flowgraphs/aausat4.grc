<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>aausat4</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>"010011110101101000110100010000110101010101000010"</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>MTU*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79, -109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TRUNCATED</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter0</value></param>
<param><key>value</key><value>3000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_3</value></param>
<param><key>value</key><value>19200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_filepath</value></param>
<param><key>value</key><value>"/home/rei/sampleAR2300IQ/full.bin"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>MTU</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1500</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>aausat4_decoded</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>target_samp_rate/(20*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_1_1</value></param>
<param><key>comment</key><value>Viterbi takes floats</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>"" + str(source_filepath) </value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>For radios where the I and Q 
streams are inverted, we need
to invert the bits to capture the 
sync word.</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0_0_1_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>comment</key><value>RS takes packed bits</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>target_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xa9</value></param>
<param><key>reset_tag_key</key><value>packet_len</value></param>
<param><key>seed</key><value>0xff</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.005</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>8</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>8</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>8</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0</value></param>
<param><key>map</key><value>[-1,1]</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>doppler_command_source</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0_0</value></param>
<param><key>decoder</key><value>dec_cc</value></param>
<param><key>mtu</key><value>MTU</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_dc_bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>filter0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
<param><key>width</key><value>filter0/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Initial decimation from radio</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>FSK Demod for 2.4k baud</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>Detect sync preamble</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>CCSDS Viterbi</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>CCSDS Scrambling</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0</value></param>
<param><key>note</key><value>CCSDS Reed Solomon</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>partial_iq_sink</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>AR2300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>445e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_port_number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1125000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>target_samp_rate</value></param>
<param><key>interp</key><value>samp_rate_3</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>satellites_fixedlen_tagger</key>
<param><key>id</key><value>satellites_fixedlen_tagger_0_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>251*8</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>satellites_fixedlen_tagger</key>
<param><key>id</key><value>satellites_fixedlen_tagger_0_0_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>251*8</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>freq_offset_dc_bias</value></param>
<param><key>radio_antenna</key><value>radio_antenna</value></param>
<param><key>radio_center_freq</key><value>radio_center_freq</value></param>
<param><key>radio_device_address</key><value>radio_device_address</value></param>
<param><key>radio_gain</key><value>radio_gain</value></param>
<param><key>radio_samp_rate</key><value>radio_samp_rate</value></param>
<param><key>radio_port_number</key><value>radio_port_number</value></param>
<param><key>radio</key><value>radio</value></param>
<param><key>target_samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>starcoder_pdu_trim_uvector</key>
<param><key>id</key><value>starcoder_pdu_trim_uvector_0</value></param>
<param><key>comment</key><value>Remove first byte Frame Size Marker (FSM)</value></param>
<param><key>end_trim_length</key><value>0</value></param>
<param><key>start_trim_length</key><value>8</value></param>
</block>
<block>
<key>starcoder_pdu_trim_uvector</key>
<param><key>id</key><value>starcoder_pdu_trim_uvector_0_0</value></param>
<param><key>comment</key><value>Remove last byte Viterbi tail</value></param>
<param><key>end_trim_length</key><value>8</value></param>
<param><key>start_trim_length</key><value>0</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value>"" + waterfall_image_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_image_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_1_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1_0</source_block_id><sink_block_id>digital_map_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1_2</source_block_id><sink_block_id>digital_additive_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0_0_1_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>starcoder_pdu_trim_uvector_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0_0</source_block_id><sink_block_id>starcoder_pdu_trim_uvector_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_1_0</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_1_0</source_block_id><sink_block_id>fec_async_decoder_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>satellites_fixedlen_tagger_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0_0</source_block_id><sink_block_id>satellites_fixedlen_tagger_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doppler_command_source</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>out</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0_0</source_block_id><sink_block_id>starcoder_pdu_trim_uvector_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>aausat4_decoded</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_fixedlen_tagger_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_fixedlen_tagger_0_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>partial_iq_sink</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_pdu_trim_uvector_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>starcoder_pdu_trim_uvector_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1_2</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
