<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_9600_ax25_transceiver</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>value</key><value>9600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_cutoff</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps_rx, 1, 0.35, 11*sps_rx*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_float</value></param>
<param><key>value</key><value>float(samp_rate)/baud_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps_rx</value></param>
<param><key>value</key><value>int(round(float(samp_rate)/baud_rate))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(20*math.pi*baud_rate/8.0)</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>ax25_payload_source</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1e-20</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.make_u8vector(fill=89, k=20)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>tx_multiply_const</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1.0/1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"header_length"</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_1</value></param>
<param><key>alpha</key><value>.01</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"header_length"</value></param>
<param><key>packet_len</key><value>16</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengthtagname</key><value>"header_length"  </value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"header_length"</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0x9c, 0x9e, 0x86, 0x82, 0x98, 0x98, 0x60, 0x86, 0xa2, 0x40, 0x40, 0x40, 0x40, 0xe1, 0x03, 0xf0]</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>descramble</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dest_callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dest_ssid</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.5</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x0</value></param>
</block>
<block>
<key>digital_symbol_sync_xx</key>
<param><key>id</key><value>digital_symbol_sync_xx_0</value></param>
<param><key>damping</key><value>.2</value></param>
<param><key>ted_gain</key><value>0.09501613+1.32802387/(1+(sps_float/28.7271)**2.541608)</value></param>
<param><key>nfilters</key><value>nfilts</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>resamp_type</key><value>digital.IR_PFB_MF</value></param>
<param><key>loop_bw</key><value>3.1416/10</value></param>
<param><key>max_dev</key><value>0.01</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>pfb_mf_taps</key><value>rrc_taps</value></param>
<param><key>sps</key><value>sps_float</value></param>
<param><key>ted_type</key><value>digital.TED_SIGNUM_TIMES_SLOPE_ML</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>doppler_command_source</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>doppler_command_source_transmit</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency_offset</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>300000</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>fsk_9600_decoded</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>baud_rate*.55</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>baud_rate*.55/2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>partial_iq_sink</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>baud_rate*sps</value></param>
<param><key>interp</key><value>usrp_samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>receiver_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>TX/RX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>receiver_frequency</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>445000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>receiver_gain</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>receiver_radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>USRP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>receiver_serial</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>satellites_hdlc_framer</key>
<param><key>id</key><value>satellites_hdlc_framer_0</value></param>
<param><key>postamble_bytes</key><value>4</value></param>
<param><key>preamble_bytes</key><value>16</value></param>
</block>
<block>
<key>satellites_nrzi_encode</key>
<param><key>id</key><value>satellites_nrzi_encode_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source_callsign</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source_ssid</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>starcoder_ax25_decoder_bm</key>
<param><key>id</key><value>starcoder_ax25_decoder_bm_0</value></param>
<param><key>descrambling</key><value>bool(descramble)</value></param>
<param><key>max_frame_len</key><value>1024</value></param>
<param><key>promisc</key><value>True</value></param>
<param><key>addr</key><value>'GND'</value></param>
<param><key>ssid</key><value>0</value></param>
<param><key>strip_headers</key><value>True</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>frequency_offset</value></param>
<param><key>radio_antenna</key><value>receiver_antenna</value></param>
<param><key>radio_center_freq</key><value>receiver_frequency</value></param>
<param><key>radio_device_address</key><value>("serial=" + receiver_serial) if receiver_serial else ""</value></param>
<param><key>radio_gain</key><value>receiver_gain</value></param>
<param><key>radio_samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>radio</key><value>receiver_radio</value></param>
<param><key>target_samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>starcoder_pmt_to_pdu</key>
<param><key>id</key><value>starcoder_pmt_to_pdu_0</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value></value></param>
<param><key>mode</key><value>1</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>transmitter_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>TX/RX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>transmitter_frequency</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>445000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>transmitter_gain</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>transmitter_serial</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_multiply_const</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>transmitter_antenna</value></param>
<param><key>center_freq0</key><value>transmitter_frequency</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>transmitter_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>("serial=" + transmitter_serial) if transmitter_serial else ""</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>usrp_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ax25_payload_source</source_block_id><sink_block_id>starcoder_pmt_to_pdu_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>digital_symbol_sync_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>starcoder_pmt_to_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>satellites_hdlc_framer_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_rms_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>starcoder_ax25_decoder_bm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>satellites_nrzi_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_symbol_sync_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doppler_command_source</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>out</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>doppler_command_source_transmit</source_block_id><sink_block_id>analog_sig_source_x_0_1</sink_block_id><source_key>out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_hdlc_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>satellites_nrzi_encode_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_ax25_decoder_bm_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>starcoder_ax25_decoder_bm_0</source_block_id><sink_block_id>fsk_9600_decoded</sink_block_id><source_key>pdu</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>partial_iq_sink</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_pmt_to_pdu_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
