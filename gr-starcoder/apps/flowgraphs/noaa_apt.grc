<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decimation</value></param>
<param><key>comment</key><value>Audio decimation after 
the quadrature demodulation</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_cutoff</value></param>
<param><key>value</key><value>20000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_transition</value></param>
<param><key>value</key><value>4e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_filepath</value></param>
<param><key>value</key><value>"/home/rei/sampleAR2300IQ/full.bin"</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>audio_decimation</value></param>
<param><key>quad_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>6</value></param>
<param><key>high_cutoff_freq</key><value>4.2e3</value></param>
<param><key>low_cutoff_freq</key><value>500</value></param>
<param><key>samp_rate</key><value>target_samp_rate/audio_decimation</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>"" + str(source_filepath) </value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>target_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>starcoder_command_source</key>
<param><key>id</key><value>doppler_command_source</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, target_samp_rate, initial_cutoff, initial_transition)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>[0.5, 0.5]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset_dc_bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>starcoder_noaa_apt_sink</key>
<param><key>id</key><value>noaa_apt_decoded</value></param>
<param><key>flip</key><value>False</value></param>
<param><key>filename_png</key><value></value></param>
<param><key>height</key><value>1800</value></param>
<param><key>width</key><value>2080</value></param>
<param><key>sync</key><value>True</value></param>
</block>
<block>
<key>starcoder_enqueue_message_sink</key>
<param><key>id</key><value>partial_iq_sink</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>AR2300</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>445e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_port_number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1125000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>target_samp_rate/audio_decimation/2</value></param>
<param><key>interp</key><value>4*4160</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>starcoder_complex_to_msg_c</key>
<param><key>id</key><value>starcoder_complex_to_msg_c_0</value></param>
<param><key>num_items</key><value>131072</value></param>
</block>
<block>
<key>starcoder_iq_only_receiver</key>
<param><key>id</key><value>starcoder_iq_only_receiver_0</value></param>
<param><key>freq_offset_dc_bias</key><value>freq_offset_dc_bias</value></param>
<param><key>radio_antenna</key><value>radio_antenna</value></param>
<param><key>radio_center_freq</key><value>radio_center_freq</value></param>
<param><key>radio_device_address</key><value>radio_device_address</value></param>
<param><key>radio_gain</key><value>radio_gain</value></param>
<param><key>radio_samp_rate</key><value>radio_samp_rate</value></param>
<param><key>radio_port_number</key><value>radio_port_number</value></param>
<param><key>radio</key><value>radio</value></param>
<param><key>target_samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>starcoder_waterfall_sink</key>
<param><key>id</key><value>starcoder_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value>"" + waterfall_image_file_path</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>rps</key><value>10</value></param>
<param><key>samp_rate</key><value>target_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>waterfall_image_file_path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doppler_command_source</source_block_id><sink_block_id>starcoder_iq_only_receiver_0</sink_block_id><source_key>out</source_key><sink_key>doppler_in</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>noaa_apt_decoded</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_complex_to_msg_c_0</source_block_id><sink_block_id>partial_iq_sink</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_complex_to_msg_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_iq_only_receiver_0</source_block_id><sink_block_id>starcoder_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
