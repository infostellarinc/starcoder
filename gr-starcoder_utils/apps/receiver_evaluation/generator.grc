<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>generator</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>const_bpsk</value></param>
<param><key>const_points</key><value>[-1, 1]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>sym_map</key><value>[0, 1]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>const_qpsk</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1+1j, 1-1j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>sym_map</key><value>[0, 1, 3, 2]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_bt</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_samp_per_sym</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_payload_length_bytes</value></param>
<param><key>value</key><value>219</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prbs_reset_len</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>variable_cc_encoder_def_0</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>1500*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TRUNCATED</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bit_rate</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>300000</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>mod_mapping.mod_string_to_id(modulation_type)</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>mod_mapping.mod_string_to_id(modulation_type)</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>str(iq_save_file)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>packet_payload_length_bytes</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>This is needed so we don't overflow  the downstream message buffers.
The appropriate fix is to rewrite the downstream PDU processing blocks
to use tagged stream blocks.</value></param>
<param><key>samples_per_second</key><value>bit_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel_noise_voltage</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>channel_noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xa9</value></param>
<param><key>reset_tag_key</key><value>"packet_len"</value></param>
<param><key>seed</key><value>0xfF</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>const_qpsk</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>fsk_bt</value></param>
<param><key>log</key><value>True</value></param>
<param><key>samples_per_symbol</key><value>fsk_samp_per_sym*2</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0_0</value></param>
<param><key>constellation</key><value>const_bpsk</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>fsk_bt</value></param>
<param><key>log</key><value>True</value></param>
<param><key>samples_per_symbol</key><value>fsk_samp_per_sym</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>fsk_bt</value></param>
<param><key>samples_per_symbol</key><value>fsk_samp_per_sym</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0</value></param>
<param><key>encoder</key><value>variable_cc_encoder_def_0</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_save_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/tmp/iq.bin"</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>mod_mapping</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
def mod_string_to_id(x):
  mapping = {
    'FSK': 0,
    'BPSK': 1,
    'QPSK': 2,
  }
  return mapping[x]
</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation_type</value></param>
<param><key>comment</key><value>TODO: Implement</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"FSK"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Takes in packed MSB bytes and outputs modulated complex</value></param>
<param><key>note</key><value>Modulation</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>comment</key><value>Takes in complex</value></param>
<param><key>note</key><value>Transmit chain</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>Convolutional encoder</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0</value></param>
<param><key>note</key><value>Append sync word</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>note</key><value>scrambling</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>note</key><value>Reed Solomon encoding</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_packets_to_send</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>1125000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>fsk_samp_per_sym*bit_rate</value></param>
<param><key>interp</key><value>int(rf_samp_rate)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>repack_pdu_bits</key>
<param><key>id</key><value>repack_pdu_bits_0</value></param>
<param><key>bits_per_input_byte</key><value>8</value></param>
<param><key>bits_per_output_byte</key><value>1</value></param>
<param><key>length_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rf_samp_rate</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rs_applied</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>satellites_encode_rs</key>
<param><key>id</key><value>satellites_encode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scrambling_applied</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>starcoder_ar2300_source</key>
<param><key>id</key><value>starcoder_ar2300_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>starcoder_utils_add_incrementing_header_pdu</key>
<param><key>id</key><value>starcoder_utils_add_incrementing_header_pdu_0</value></param>
</block>
<block>
<key>starcoder_utils_add_sync_pdu</key>
<param><key>id</key><value>starcoder_utils_add_sync_pdu_0</value></param>
<param><key>byte_length</key><value>sync_word_num_bytes</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
</block>
<block>
<key>starcoder_utils_message_router</key>
<param><key>id</key><value>starcoder_utils_message_router_0</value></param>
<param><key>output_index</key><value>rs_applied</value></param>
</block>
<block>
<key>starcoder_utils_message_router</key>
<param><key>id</key><value>starcoder_utils_message_router_0_0</value></param>
<param><key>output_index</key><value>scrambling_applied</value></param>
</block>
<block>
<key>starcoder_utils_message_router</key>
<param><key>id</key><value>starcoder_utils_message_router_0_0_0</value></param>
<param><key>output_index</key><value>viterbi_applied</value></param>
</block>
<block>
<key>starcoder_utils_prbs_source_b</key>
<param><key>id</key><value>starcoder_utils_prbs_source_b_0</value></param>
<param><key>num_packets</key><value>num_packets_to_send</value></param>
<param><key>packet_len</key><value>packet_payload_length_bytes*8</value></param>
<param><key>reset_len</key><value>prbs_reset_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>0x24804321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word_num_bytes</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>rf_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>rf_samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>viterbi_applied</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>digital_constellation_modulator_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>starcoder_utils_add_incrementing_header_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>starcoder_utils_add_sync_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_1</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>repack_pdu_bits_0</source_block_id><sink_block_id>starcoder_utils_message_router_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_encode_rs_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_encode_rs_0</source_block_id><sink_block_id>repack_pdu_bits_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_ar2300_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>starcoder_utils_add_incrementing_header_pdu_0</source_block_id><sink_block_id>starcoder_utils_message_router_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_add_sync_pdu_0</source_block_id><sink_block_id>starcoder_utils_message_router_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0</source_block_id><sink_block_id>repack_pdu_bits_0</sink_block_id><source_key>out0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0</source_block_id><sink_block_id>satellites_encode_rs_0</sink_block_id><source_key>out1</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0</source_block_id><sink_block_id>starcoder_utils_add_sync_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>out1</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0_0</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>out1</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_prbs_source_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
