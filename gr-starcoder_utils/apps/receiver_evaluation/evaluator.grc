<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>evaluator</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_packet_length_bytes</value></param>
<param><key>value</key><value>259</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_payload_length_bytes</value></param>
<param><key>value</key><value>219</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prbs_reset_len</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>variable_cc_decoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>2048</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TRUNCATED</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_1_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/rei/sampleAR2300IQ/mypacket_2018-12-17T04-27-31</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>max_packet_length_bytes</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0</value></param>
<param><key>bits_per_byte</key><value>1</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0xa9</value></param>
<param><key>reset_tag_key</key><value>packet_len</value></param>
<param><key>seed</key><value>0xff</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0</value></param>
<param><key>map</key><value>[-1,1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>expected_packet_length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>259</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>variable_cc_decoder</value></param>
<param><key>mtu</key><value>1500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>folder_source</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/home/rei/sampleAR2300IQ/encoded_packets</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>comment</key><value>Input and output are unpacked PDU</value></param>
<param><key>note</key><value>Viterbi decoding</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>comment</key><value>Input and output are unpacked PDU</value></param>
<param><key>note</key><value>Remove sync word</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>comment</key><value>Input and output are unpacked PDU</value></param>
<param><key>note</key><value>Descramble</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>comment</key><value>Input is packed PDU</value></param>
<param><key>note</key><value>Reed Solomon decoding</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0_0_0_0</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>comment</key><value>Input is unpacked PDU</value></param>
<param><key>note</key><value>Analyze decoded</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_1</value></param>
<param><key>alias</key><value>Scrambling</value></param>
<param><key>comment</key><value>Output is unpacked PDU</value></param>
<param><key>note</key><value>Packet source</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_packets_to_send</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>repack_pdu_bits</key>
<param><key>id</key><value>repack_pdu_bits_0</value></param>
<param><key>bits_per_input_byte</key><value>8</value></param>
<param><key>bits_per_output_byte</key><value>1</value></param>
<param><key>length_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>repack_pdu_bits</key>
<param><key>id</key><value>repack_pdu_bits_0_0_0</value></param>
<param><key>bits_per_input_byte</key><value>1</value></param>
<param><key>bits_per_output_byte</key><value>8</value></param>
<param><key>length_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rs_applied</value></param>
<param><key>comment</key><value>TODO: Implement</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>satellites_decode_rs</key>
<param><key>id</key><value>satellites_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>scrambling_applied</value></param>
<param><key>comment</key><value>TODO: Implement</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>starcoder_pdu_trim_uvector</key>
<param><key>id</key><value>starcoder_pdu_trim_uvector_0</value></param>
<param><key>end_trim_length</key><value>0</value></param>
<param><key>start_trim_length</key><value>sync_word_num_bytes*8</value></param>
</block>
<block>
<key>starcoder_utils_folder_source_pdu</key>
<param><key>id</key><value>starcoder_utils_folder_source_pdu_0</value></param>
<param><key>delay_between_packets_ms</key><value>0</value></param>
<param><key>folder_name</key><value>folder_source</value></param>
<param><key>packet_length_bytes</key><value>expected_packet_length</value></param>
</block>
<block>
<key>starcoder_utils_message_router</key>
<param><key>id</key><value>starcoder_utils_message_router_0</value></param>
<param><key>output_index</key><value>viterbi_applied</value></param>
</block>
<block>
<key>starcoder_utils_message_router</key>
<param><key>id</key><value>starcoder_utils_message_router_0_0</value></param>
<param><key>output_index</key><value>scrambling_applied</value></param>
</block>
<block>
<key>starcoder_utils_message_router</key>
<param><key>id</key><value>starcoder_utils_message_router_0_0_0</value></param>
<param><key>output_index</key><value>rs_applied</value></param>
</block>
<block>
<key>starcoder_utils_prbs_sink_pdu</key>
<param><key>id</key><value>starcoder_utils_prbs_sink_pdu_0</value></param>
<param><key>num_packets</key><value>num_packets_to_send</value></param>
<param><key>packet_len_bits_no_header</key><value>packet_payload_length_bytes*8</value></param>
<param><key>reset_len</key><value>prbs_reset_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word_num_bytes</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>viterbi_applied</value></param>
<param><key>comment</key><value>TODO: Implement</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_1_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1_0</source_block_id><sink_block_id>digital_map_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1_0_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>repack_pdu_bits_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_1_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_1_0_0</source_block_id><sink_block_id>repack_pdu_bits_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>starcoder_pdu_trim_uvector_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>repack_pdu_bits_0</source_block_id><sink_block_id>starcoder_utils_message_router_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>repack_pdu_bits_0_0_0</source_block_id><sink_block_id>starcoder_utils_message_router_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_decode_rs_0</source_block_id><sink_block_id>starcoder_utils_prbs_sink_pdu_0</sink_block_id><source_key>out</source_key><sink_key>corrected</sink_key></connection>
<connection><source_block_id>starcoder_pdu_trim_uvector_0</source_block_id><sink_block_id>starcoder_utils_message_router_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_folder_source_pdu_0</source_block_id><sink_block_id>repack_pdu_bits_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_folder_source_pdu_0</source_block_id><sink_block_id>starcoder_utils_prbs_sink_pdu_0</sink_block_id><source_key>out</source_key><sink_key>all</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0</source_block_id><sink_block_id>starcoder_pdu_trim_uvector_0</sink_block_id><source_key>out0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1_0</sink_block_id><source_key>out1</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0</source_block_id><sink_block_id>repack_pdu_bits_0_0_0</sink_block_id><source_key>out0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1_0_0</sink_block_id><source_key>out1</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0_0</source_block_id><sink_block_id>starcoder_utils_prbs_sink_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>corrected</sink_key></connection>
<connection><source_block_id>starcoder_utils_message_router_0_0_0</source_block_id><sink_block_id>satellites_decode_rs_0</sink_block_id><source_key>out1</source_key><sink_key>in</sink_key></connection>
</flow_graph>
